PROGRAM MAIN
VAR
	Value1 : INT;
	Value2 : INT;
END_VAR

END_PROGRAM
